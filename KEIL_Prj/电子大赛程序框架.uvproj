# Keil uVision project 电子大赛程序框架.uvproj, settings and files
target 电子大赛程序框架 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 电子大赛程序框架 +hex
  c flags: Optimize=8 SizeSpeed=1
  group ABS_TASK
    ../SOFTWARE/ABS_TASK/: absTask.c
  group TASK
    ../SOFTWARE/TASK/: task.c setup.c mode.c
  group OS
    ../SOFTWARE/RTOS/: Conf_tny.A51
  group COMMON_SOFTWARE
    ../SOFTWARE/COMMON_SOFTWARE/DATA_SCOPE/: DataScope_DP.c
    ../SOFTWARE/COMMON_SOFTWARE/STORAGE/: storage.c
  group DEVICES
    ../HARDWARE/DEVICES/BUTTON/: BUTTON.C
    ../HARDWARE/DEVICES/LED/: LED.c
    ../HARDWARE/DEVICES/MOTOR/DC_MOTOR/: MOTOR.C
    ../HARDWARE/DEVICES/MOTOR/SERVO/: SERVO.C
    ../HARDWARE/DEVICES/MOTOR/STEP_MOTOR/: STEP_MOTOR.C
    ../HARDWARE/DEVICES/COMMON_DEVICES/RELAY/: RELAY.C
    ../HARDWARE/DEVICES/SENSOR/ANGLE/: ANGLE.C
    ../HARDWARE/DEVICES/SENSOR/MPU6050/: MPU6050.C
    ../HARDWARE/DEVICES/DISPLAY/1602/: LCD1602.c
    ../HARDWARE/DEVICES/SENSOR/MPU9250/: MPU9250.C
    ../HARDWARE/DEVICES/COMMON_DEVICES/74H/: 74HC595.C
  group COMMON_HARDWARE
    ../HARDWARE/COMMON_HARDWARE/: fixedPulser.c
  group BSP
    ../HARDWARE/BSP/: ADC.c delay.c GPIO.c PCA.c stc15_pwm.c timer.c USART1.C stc15_eeprom.c
  group ALGORITHM
    ../SOFTWARE/ALGORITHM/PID/: PID.c
    ../SOFTWARE/ALGORITHM/FILTER/: FILTER.C
